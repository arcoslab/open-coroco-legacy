# Repository arcoslab/open-coroco-legacy

File README.md:

open-coroco
===========

COmpliant RObot COntroller is a free software project aiming to create an impedance controller based on a STM32F4 microcontroller using bldc motors and strain gauges.

## KiCad design resolver_board/kicad/AD2S1210/AD2S1210_AD8662.kicad_pcb

Parts:
AD1: AD2S1210
C1, C7, C10: 4.7µ
C2, C3, C5, C9, C18: 10n
C4, C8: 20p
C6, C15, C20, C21: 10µ
C11: 2.2µ
C12, C13: 120p
C14: 220µ
C16, C17, C19: 100n
D1, D2, D3, D4, D5: DIODE
Drill1: Drill1
Drill2: Drill2
Drill3: Drill3
Drill4: Drill4
F1: FUSE
IC1: AD8662
K1: JP_1
K2: V_control
K3: Power
P1: conn_stm32f4
P2: AOUT
P3: conn_motor_control
P4: JP_2
P5: JP_3
Q1: RECOM
Q2, Q4: BC846; SOT-23
Q3, Q5: BC856; SOT-23
R1: 1k
R2, R9, R14, R21: 2.2k
R3, R25: 8.66k
R4, R6, R18, R20: 10k
R5, R19: 22k
R7, R8, R15, R16: 3.3
R10, R11, R12, R13: 4.7
R17, R27: 13.3k
R22, R23: 0k
R24, R26: 15.4k
R28, R29, R30, R31: 2.66 K
X1: 8.192 MHZ

Connections:
+5V: AD1.6 (DV_dd), AD1.43 (AV_DD), C1.1, C3.2, C5.1, C7.2, C17.1, C18.1, C21.1, K2.1, Q1.3 (V_OUT), R28.2, R30.1
/12V_a: F1.1, K3.3
/A0: AD1.36 (A1), AD1.37 (A0), P1.4, P3.4, R1.1
/COS: AD1.45 (COS), P2.6
/COSLO: AD1.44 (COSLO), P2.5, R28.1, R29.1
/EXC: AD1.38 (EXC), R18.1
/Hall3: K1.3, P3.37
/NC: P1.48, P3.48
/NRST: P1.6, P3.6
/OUT_EXC: C13.1, R12.1, R13.2, R25.2, R26.2, R27.2
/OUT_~EXC: C12.1, R3.2, R10.1, R11.2, R17.2, R24.2
/PA0: P1.12, P3.12
/PA1: P1.11, P3.11
/PA2: P1.14, P3.14
/PA4: P1.16, P3.16
/PA5: P1.15, P3.15
/PA6: P1.18, P3.18
/PA7: P1.17, P3.17
/PB0: P1.22, P3.22
/PB1: P1.21, P3.21
/PB2: P1.24, P3.24
/PB10: P1.34, P3.34
/PB11: P1.35, P3.35
/PB12: P1.36, P3.36
/PB15: P1.39, P3.39
/PC0: P1.8, P3.8
/PC1: P1.7, P3.7
/PC2: P1.10, P3.10
/PC4: P1.20, P3.20
/PC5: P1.19, P3.19
/PD9: P1.41, P3.41
/PD10: P1.42, P3.42
/PD11: P1.43, P3.43
/PD12: P1.44, P3.44
/PD13: P1.45, P3.45
/PD14: P1.46, P3.46
/PD15: P1.47, P3.47
/PE7: P1.25, P3.25
/PE8: P1.26, P3.26
/PE9: P1.27, P3.27
/PE10: P1.28, P3.28
/PE11: P1.29, P3.29
/PE12: P1.30, P3.30
/PE13: P1.31, P3.31
/PE14: P1.32, P3.32
/PE15: P1.33, P3.33
/SCLK: AD1.13 (DB13/SCLK), P1.38, P3.38
/SDI: AD1.12 (DB14/SDI), P1.40, P3.40
/SDO: AD1.11 (DB15/SDO), K1.1
/SDO_HALL3: K1.2 (PM), P1.37
/SIN: AD1.41 (SIN), P2.3
/SINLO: AD1.42 (SINLO), P2.4, R30.2, R31.2
/V_DRIVE: AD1.3 (~RD), AD1.18 (V_DRIVE), C9.1, C10.1, P1.3, P3.3
/~EXC: AD1.39 (~EXC), R4.1
/~SAMPLE: AD1.10 (~SAMPLE), P1.9, P3.9
/~WR: AD1.4 (~WR~/~FSYNC), P1.13, P3.13
GND: AD1.1 (RES1), AD1.2 (~CS), AD1.5 (DGND), AD1.9 (~SOE), AD1.19 (DGND), AD1.40 (AGND), AD1.48 (RES0), C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.1, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, D5.1 (A), IC1.4 (V-), K2.2 (PM), K3.1, K3.2 (PM), P1.1, P1.2, P1.5, P1.23, P1.49, P1.50, P3.1, P3.2, P3.5, P3.23, P3.49, P3.50, Q1.2 (GND), Q3.3 (C), Q5.3 (C), R6.1, R9.1, R14.1, R20.1, R29.2, R31.1
unnamed: AD1.33 (~RESET), C11.2, R1.2
unnamed: D3.2 (K), D4.1 (A), R23.1
unnamed: D3.1 (A), R15.2
unnamed: Q4.1 (B), R15.1, R21.2
unnamed: D4.2 (K), R16.1
unnamed: Q3.2 (E), R11.1
unnamed: Q2.2 (E), R10.2
unnamed: Q3.1 (B), R7.2, R9.2
unnamed: Q5.2 (E), R13.1
unnamed: Q4.2 (E), R12.2
unnamed: Q5.1 (B), R14.2, R16.2
unnamed: IC1.5 (+IN_B), R19.2, R20.2
unnamed: IC1.7 (OUT_B), R23.2
unnamed: IC1.3 (+IN_A), R5.2, R6.2
unnamed: C13.2, IC1.6 (-IN_B), P5.1, P5.3, P5.5, R18.2
unnamed: P4.2, R17.1
unnamed: P4.4, R24.1
unnamed: P4.6, R3.1
unnamed: P5.2, R27.1
unnamed: P5.4, R26.1
unnamed: P5.6, R25.1
unnamed: AD1.46 (REFBYP), C2.1, C6.1
unnamed: IC1.1 (OUT_A), R22.1
unnamed: C12.2, IC1.2 (-IN_A), P4.1, P4.3, P4.5, R4.2
unnamed: D2.2 (K), R7.1
unnamed: D1.1 (A), R8.2
unnamed: Q2.1 (B), R2.2, R8.1
unnamed: D1.2 (K), D2.1 (A), R22.2
unnamed: AD1.7 (CLKIN), C4.1, X1.1
unnamed: AD1.8 (XTALOUT), C8.1, X1.2
VCC: C14.1, C15.1, C16.1, C19.1, C20.1, D5.2 (K), F1.2, IC1.8 (V+), K2.3, Q1.1 (V_IN), Q2.3 (C), Q4.3 (C), R2.1, R5.1, R19.1, R21.1

Board: 2 copper layers, 93.0 x 78.7 mm, 78 parts (0 on the bottom side), 88 nets.

## KiCad design resolver_board/kicad/AD2S1210/AD2S1210.kicad_pcb

Board: 2 copper layers, 35 parts (0 on the bottom side), 40 nets, no tracks yet.

Parts:
AD1: AD2S1210; LQFP48
C1, C7: 4.7µ; Elko_vert_DM5_RM2
C2, C3, C5, C9, C18: 10n; c_0805
C4, C8: 20p; c_0805
C6: 22µ; Elko_vert_DM6-3_RM2-5
C10: 4.7µ; c_0805
C11: 2.2µ; c_0805
C12, C13: 120p; c_0805
C14: 220µ; Elko_vert_DM10_RM5
C15: 10µ; Elko_vert_DM5_RM2
C16, C17: 100n; c_0805
OP1, OP2: OPA561; tssop-20
P1: CONN_25X2; PIN_ARRAY_STM32_25X2
Q1: RECOM; SIP-3
R1: 1k; c_0805
R2, R3: 15.4k; c_0805
R4, R5, R9, R11: 10k; c_0805
R6, R7: 390k; c_0805
R8, R10: 22k; c_0805
X1: 8.192 MHZ; crystal_ATS

Connections:
/A0: AD1.36, AD1.37, P1.4, R1.1
/COS: AD1.45, P1.10
/COSLO: AD1.44, P1.12
/EXC: AD1.38, R5.1
/OUT_EXC: C13.1, OP2.7, P1.24, R3.1
/OUT_~EXC: C12.1, OP1.7, P1.22, R2.1
/SCLK: AD1.13, P1.38
/SDI: AD1.12, P1.40
/SDO: AD1.11, P1.37
/SIN: AD1.41, P1.18
/SINLO: AD1.42, P1.16
/V_DRIVE: AD1.3, P1.3
/~EXC: AD1.39, R4.1
/~SAMPLE: AD1.10, P1.9
/~WR: AD1.4, P1.13
GND: AD1.19, C14.2, C15.2, C16.2, C17.2, C18.2, OP1.5, OP2.5, Q1.2
unnamed: AD1.6, C3.2, C7.2
unnamed: AD1.5, C3.1, C7.1
unnamed: C9.2, C10.2
unnamed: AD1.18, C9.1, C10.1
unnamed: AD1.9, C4.2, C8.2
unnamed: C17.1, C18.1, Q1.3
unnamed: AD1.40, C1.2, C5.2
unnamed: AD1.1, AD1.2, AD1.48, C2.2, C6.2
unnamed: AD1.8, C8.1, X1.2
unnamed: AD1.7, C4.1, X1.1
unnamed: C14.1, C15.1, C16.1, Q1.1
unnamed: OP1.8, R6.2
unnamed: C12.2, OP1.3, R2.2, R4.2
unnamed: OP2.8, R7.2
unnamed: C13.2, OP2.3, R3.2, R5.2
unnamed: OP2.2, R10.2, R11.1
unnamed: OP2.4, R11.2
unnamed: OP2.6, R7.1, R10.1
unnamed: AD1.33, C11.2, R1.2
unnamed: AD1.43, C1.1, C5.1
unnamed: AD1.46, C2.1, C6.1
unnamed: OP1.2, R8.2, R9.1
unnamed: OP1.4, R9.2
unnamed: OP1.6, R6.1, R8.1

## KiCad design src_PCB_Mobile_base/Three-phase bridge.kicad_pcb

Parts:
1N1, 1N2, 1N3: 1N4003
BT1: BATTERY_12V
BT2: BATTERY_48
C1, C2, C12, C13: 1000uF
C3, C4, C5, C6, C14, C15, C17: 100uF
C7: 100u
C8, C10: 0.1uF
C9: 2.2uF
C11: 0.33uF
C16: 10uF
D1, D2, D3, D4, D5: LED
D6, D8, D10: LED VERDE
D7, D9, D11: LED ROJO
H1, H2, H3: HALL_SENSOR
INA1, INA2: INA148
IR1, IR2, IR3: IR_2110
L1: L7805CV
LF1: LF33CV
M1, M2: MCP6022-I/P
P1, P4, P5: CONN_1
P2, P6: POWER_FUSE
P3: CONN_2
P7, P8, P9, P10: CONN_1
R1, R3, R13, R15, R17, R18, R27: 4.02k
R2, R4, R14, R16, R19, R20: 36
R5, R7, R8, R9, R10, R11, R12, R21, R22, R23, R24, R25, R26, R28: 1k
R6: 18k
R_Shunt_1, R_Shunt_2: 0.05
S1, S2, S3, S4, S5, S6: IRF1010N; TO220
STM32_CONN1: CONN_STM32_25X2

Connections:
+3.3V: C9.1, INA1.7 (V+), INA2.7 (V+), LF1.2 (OUTPUT), M1.8 (VDD), M2.8 (VDD)
+5V: C10.2, H1.3, H2.3, H3.3, L1.2 (OUTPUT)
+48V: C12.1, C13.1, C14.1, C15.1, D5.1 (A), P3.1, P6.1, R1.2, R6.1, R13.2, R17.2, S1.3 (D), S3.3 (D), S5.3 (D)
GND: BT1.2 (-), BT2.2 (-), C1.2, C2.2, C3.2, C4.2, C8.1, C9.2, C10.1, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, H1.1, H2.1, H3.1, INA1.4 (V-), INA2.4 (V-), IR1.2 (COM), IR1.13 (VSS), IR2.2 (COM), IR2.13 (VSS), IR3.2 (COM), IR3.13 (VSS), L1.3 (Ground), LF1.3 (Ground), M1.4 (Vss), M2.4 (Vss), R3.2, R10.1, R12.2, R15.2, R18.2, R24.2, R25.2, R26.2, R27.1, R28.2, S2.1 (S), S4.1 (S), S6.1 (S), STM32_CONN1.1 (GND), STM32_CONN1.2 (GND), STM32_CONN1.49 (GND), STM32_CONN1.50 (GND)
unnamed: IR3.7 (HO), R19.1
unnamed: 1N3.2 (K), C7.1, IR3.6 (VB)
unnamed: IR1.1 (Lo), R4.1
unnamed: IR1.7 (HO), R2.1
unnamed: 1N1.2 (K), C5.1, IR1.6 (VB)
unnamed: IR3.1 (Lo), R20.1
unnamed: M2.6 (VinB-), M2.7 (VoutB), STM32_CONN1.14 (Ud_PA3)
unnamed: IR1.10 (HIN), STM32_CONN1.28 (A+_PE9)
unnamed: IR2.10 (HIN), STM32_CONN1.30 (B+_PE11)
unnamed: IR2.1 (Lo), R16.1
unnamed: IR2.7 (HO), R14.1
unnamed: 1N2.2 (K), C6.1, IR2.6 (VB)
unnamed: M2.3 (VinA+), R7.2, R12.1
unnamed: IR3.10 (HIN), STM32_CONN1.32 (C+_PE13)
unnamed: D2.1 (A), H1.2, R21.2, STM32_CONN1.34 (Hall1_PE15)
unnamed: IR1.12 (LIN), STM32_CONN1.25 (A-_PE8)
unnamed: IR2.12 (LIN), STM32_CONN1.27 (B-_PE10)
unnamed: IR3.12 (LIN), STM32_CONN1.29 (C-_PE12)
unnamed: INA2.2 (-In), P4.1, R_Shunt_2.2
unnamed: D3.1 (A), H2.2, R22.2, STM32_CONN1.36 (Hall2_PB11)
unnamed: D1.2 (K), R28.1
unnamed: D10.2 (K), D11.1 (A), R1.1, R3.1
unnamed: M1.1 (VoutA), R9.2, STM32_CONN1.12 (isA_PA1)
unnamed: D5.2 (K), R27.2
unnamed: INA1.6 (Out), M1.3 (VinA+)
unnamed: M1.2 (VinA-), R5.2, R9.1
unnamed: D6.2 (K), D7.1 (A), R17.1, R18.1
unnamed: D8.2 (K), D9.1 (A), R13.1, R15.1
unnamed: INA2.6 (Out), M1.5 (VinB+)
unnamed: M1.7 (VoutB), R11.1, STM32_CONN1.13 (isB)
unnamed: M1.6 (VinB-), R8.2, R11.2
unnamed: D4.1 (A), H3.2, R23.2, STM32_CONN1.38 (Hall3_PB15)
unnamed: INA1.2 (-In), P1.1, R_Shunt_1.2
unnamed: C7.2, D6.1 (A), D7.2 (K), IR3.5 (Vs), P5.1, S2.3 (D), S5.1 (S)
unnamed: M2.5 (VinB+), R6.2, R10.2
unnamed: C5.2, D10.1 (A), D11.2 (K), INA1.3 (+In), IR1.5 (Vs), R_Shunt_1.1, S1.1 (S), S4.3 (D)
unnamed: C6.2, D8.1 (A), D9.2 (K), INA2.3 (+In), IR2.5 (Vs), R_Shunt_2.1, S3.1 (S), S6.3 (D)
unnamed: BT2.1 (+), P6.2
unnamed: BT1.1 (+), P2.2
unnamed: INA1.1 (Ref), INA2.1 (Ref), M2.1 (VoutA), M2.2 (VinA-), R5.1, R8.1
unnamed: R20.2, S2.2 (G)
unnamed: R19.2, S5.2 (G)
unnamed: R16.2, S6.2 (G)
unnamed: R14.2, S3.2 (G)
unnamed: R2.2, S1.2 (G)
unnamed: R4.2, S4.2 (G)
unnamed: D2.2 (K), R24.1
unnamed: D4.2 (K), R26.1
unnamed: D3.2 (K), R25.1
VCC: 1N1.1 (A), 1N2.1 (A), 1N3.1 (A), C1.1, C2.1, C3.1, C4.1, C8.2, C11.2, D1.1 (A), IR1.3 (VCC), IR2.3 (VCC), IR3.3 (VCC), L1.1 (Input), LF1.1 (Input), P2.1, P3.2 (PM)
VDD: C16.1, C17.1, IR1.9 (VDD), IR2.9 (VDD), IR3.9 (VDD), R7.1, R21.1, R22.1, R23.1, STM32_CONN1.3 (VDD), STM32_CONN1.4 (VDD)

Board: 2 copper layers, 159.5 x 57.5 mm, 92 parts (28 on the bottom side), 55 nets.

## KiCad design trabajo/kicad/Copter/copter.kicad_pcb

Board: 2 copper layers, 20 parts (0 on the bottom side), 10 nets, no tracks yet.

Parts:
C1, C2, C3, C4, C6: 100nF; c_tant_A
C5, C7, C8: 10µF; c_tant_A
IC1: MAX7456; tssop-20
P1: JTAG; PIN_ARRAY_20X2
R1, R4, R5: 33 R; c_tant_D
R2, R3, R6, R7: 10K; c_tant_D
R8: 0K; c_tant_D
R9: 120K; c_tant_D
U1: STM32F4-C64; LQFP64

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.2, C7.2, P1.4, P1.7, R2.2, R3.2, R6.2, R7.2, U1.13
/RESET: P1.6, U1.56
/TCK: P1.1, R7.1, U1.49
/TDI: P1.9, R2.1, U1.50
/TDO: P1.3, R6.1, U1.55
/TMS: P1.5, R3.1, U1.46
/USB_D+: R4.2, U1.45
/USB_D-: R1.2, U1.44
/USB_VBUS: R5.2, U1.42
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, P1.2, P1.10, R8.1, U1.12

## Commit log (part)

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2014-02-15 DTC output voltage vector were disabled for testing the open loop starting.
2014-02-15 Se copió el contenido de src1 a src1_openloop para modificar el funcionamiento a lazo cerrado.
2014-02-15 Debugging DTC. When DTC torque reference is inverted the torque still bounces between positive and negative. Apart from that, It has been enabled a print option that prints most of the important vari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
2014-02-15 Connecting SVM to DTC.
2014-02-15 DTC_timer_init function sets the pwm in edge_aligned instead of center_aligned. This allows to duplicate the speed and have an actual value of the voltage every cycle.
2014-02-15 Testing the P and I constants for the sensorless PI controller.
2014-02-15 PI for the sensorless controller has been somehow sintonized. It is still not the ideal.
2014-02-15 Close-loop DTC-SVM has been tested on the ntm. Also the attenuation of the pwm has been set to 0 when off and 1 when on. The real attenuation for the voltage is decided by the SVM code when it calcul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
2014-02-15 Working on the DTC-SVM close-loop example.
2014-02-15 The protobard burned with the 10A that ran through the three-phace bridge. It now has been replaced with a soldered breadboard an now the tests are run in it. The problem right now is that the shunt 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
    Now that we have a soldered and fixed version of the bridge the tests for increasing the frequency have been executed. The error encountered was that the fast_cos and fast_sine were programmed to wor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
2014-02-15 Look-up tables for the sine, cosine, atan and vector angle have been implemented and tested. Although they work correctly and fast, the table size needs to increased so that the resulting angles and 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
2014-02-15 The deadtime has been disabled in the code due to the decreasing in the swithing time of the transistor. It was achieved reducing the gate resistances from 1000Ohms to 36Ohms. Now the voltage waves a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
    # Please enter the commit message for your changes. Lines starting
2014-02-15 The sensorless speed controller is working up to 200Hz. The difference between the hall sensor and sensorless frequency was due to having divided the calculus from 1 to 2 cycles, so now the TICK_PERI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
2014-02-15 sensorless PID torque controller has been programmed and tested. It is not woking properly yet. Below 1Nm the motor rotates at a relatively constante pace, but above 1.3 it starts accelerationg so fa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
2014-02-15 The two INA148 have been wired.
2014-02-15 Kicad pcb has been separated into three bloks: stm32 connections, three-phase bridge and current sensing. The idea is to have the current operational and diffential amplifiers as close as possible to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
2014-02-15 Updating the three parts of the pcb.
2014-02-15 PCB: Module T0-220 has been modified so that pin number 4 (for heat sink) is electrically connected to pin 3 (drain). Now whe the fill zones are filled, the heatsinks are connected to the PCB dissipa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
2014-02-15 PCB: Some capacitor were moved in order to reduce the final PCBarea. Now it is 5.80in x5.72in.
2014-02-15 INA148s and MCP6s have been gotten closer.
2014-02-15 This is the PCB before editing the fillzones, paths and clearance.
2014-02-15 Added exceptions for Serial port and Ctrl C.
2014-02-15 Fillzones completed. However, the schematic is damaged, looks incomplete and has interrogation signs in some modules.
2014-02-15 Before deleting fillzones.
2014-02-15 PCB: All resistances and most of capacitors have been replaced by their SMD counter parts. Required space have been sustancially reduced.
2014-02-15 printing functions have been modified to adapt to the new sending-byte serial communication. Still debugging.
2014-02-15 Python can now plot data from the stm32f4.
2014-02-15 PCB: the hall-effect current sensors have been added. Python: multiple graphics have been enabled within a figure
2014-02-15 Testing the cycles a print takes.
2014-02-15 PCB update.
2014-02-15 Adding fillzones to the PCB.
2014-02-15 The fillzones for GND and 48V where added.
2014-02-15 Working with lists didn't worked as expected. It complicates discarting an entire transmition when just a ingle data has been detected as containing errors.
2014-02-15 Before returning to the original python file
2014-02-15 Checksum of transmitted bytes has been implemented in python and the stm32. In order to reduce the amount of data that has to be transmitted, and therefore the resultant transmition errors that oblig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
2014-02-15 Serial code in python is capable if getting the whole sting with data in abouth 200 cycles, or just 20 for a single group of values. Now working on the plotting functions.
2014-02-15 Python fuction for communicating with the stm32f4 have been changed to work with lists instead of just floats for storing data in order to allow pointer-like functions. Just the print-on-screen optio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
2014-02-15 The python code can now print data to a csv file and plot such data according to the preselected set of values established by print_selection. The next step is the creation of a routine for starting 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
2014-02-15 Print functions have been added all over the transmitting code to find out what is wrong.
2014-02-15 Debugging the finite state machine.
2014-02-15 Carolina's Update: cd_car files updated.
2014-02-15 Committing gitignore.
2014-02-15 Fixing errors of python code for testing torque control.
2014-02-15 speed controller for maximum acceleration ( picontrol=0.0005 cte )
2014-02-15 Testing PI for torque.
2014-02-15 Still testing and looking for mayor errors.
2014-02-15 Debugging SVM, checking SVM and DTC equations.
2014-02-16 fixing libopencm3 checkedout version
2014-02-16 Even though a low pass filter is being used for the Flux-linkage, the frequency changes drastically due to the distorted measured currents. As a solution a low pass filter might be applied to the cur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
2014-02-16 ad2s1210 now reading status
2014-02-18 Testing speed PI...
2014-02-19 AD2S1210 reading and writing macros. Reading pos and vel
2014-02-20 PCB schematic updated.
2014-03-07 Updating PCB design.
2014-03-15 Open loop controller adjusted
2014-03-24 PCB: Fixed missing connection between pins 5 from the IRF2110 to the shunt resistors. The pdf generation for the laser cutter is still pending.
2014-04-07 Adapting the code for forcing the rotor to take an initial angle.
2014-04-08 Corroborating voltage levels for ADC current reading.
2014-04-09 Debugging and testing the PCB for the Vref!=1.5V (If it is not exactly 1.5 the currents are calculate wrongly)
2014-04-10 With a load angle of 15 the rotor can spin. First the motor does not move, then it vibrates , then it vibrates more, and finally it spins really fast. Basically the algorithm is working, the problem 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
2014-04-12 Testing flux linkage initial position.
2014-04-15 Testing pulse generation for initial rotor position identification.
2014-04-15 Before getting the first semi-estimation of an initial rotor angle.
2014-04-17 Testing without voltage open loop, just DTC-SVM load_angle=5°
2014-04-19 Tested condition for flux-linkage=permanente_magnet_flux=0.0016 are 40%Ud when wcutoff=25Hz. Above 40% the flux-linkage surpaces such a value, and the graph psisQ vs psisD is not centered around cero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
2014-04-20 The program infinetely retries plotting graphs.
2014-04-21 Testing load angles and the confusing torque inversion.
2014-04-30 Testing average mean current filter.
2014-05-02 Testing current offset.
2014-05-04 Testing different configurations for achieving a positive torque.
2014-05-06 add AD2S1210
2014-05-09 After having changed the PCB to handle 56V instead of 12V.
2014-05-12 Testing DTC-SVM open loop at 45° on Baldor.
2014-05-15 After testing reference voltage adjusments for low value currents.
2014-05-20 Adding code for strain gauge.
2014-05-28 Testing DTC-SVM after having fixed the SVM duty cycles. The flux-linkage looks better, but the relation load angle - torque is not quite right. Also, the flux-linkage magnitude does not keep constant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
2014-06-02 Speed control based on control of the voltage frequency has been tested. P constant still has to be tuned.
2014-06-02 Operational close-loop Speed controller based on voltage frequency.
2014-06-05 testting negative frequency with two hall sensors.
2014-06-12 Speed controller with extra_voltage_angle proportional the actual frequency.
2014-06-16 Before testing admittance control.
2014-08-01 Before debugging for presentation.
2014-09-24 src_KalmanFilter
2014-09-25 Agregado esquemático del Puente Wheatstone
2014-09-30 Creating a new PCB directory for the mobile base.
2014-09-30 modificacion de modulos en fichero .kicad_pcb
2014-09-30 iniciando el reacomodo de los modulos
2014-10-04 reduccion adicional pcb, se va iniciar el ruteo
2014-10-10 Distribucion modular mas espaciada, algunas pistas GND y 48V
2014-10-14 pcb potencia sin zonas de relleno 2
2014-10-14 PCB potencia con zonas relleno 2
2014-11-19 JOINT STABLE VERSION [updating .gitignore]
2014-11-22 src1_openloop for baldor working at 12V coil order white red black motor n3
2014-11-26 baldor_control: fixed some bugs associated with the hall emulation. baldor settings for 24V added
2014-11-29 baldor_control: serial conf init function
2014-12-01 baldor control: excitation voltage
2014-12-02 baldor control: working both directions! Now a PID controller, better response! Some bug fixes
2014-12-02 baldor control: cleaning up
2014-12-02 baldor control: fix: strong jump at beginning avoided, raw_pos_last=raw_pos for first measurement
2014-12-09 cambio de valores errones
2015-01-16 testing confusing loss of smothness when 85Hz<f<125Hz
2015-01-27 silkscreen new
2015-01-29 resolver_test: include fixed
2015-02-04 Adding capability for flashing a determined STM32 according to its position
2015-02-08 testing bidirectional connection
2015-02-09 bidirectional communication between 2 stm32
2015-02-12 fixing disconnection of stm32_3
2015-02-16 NewFolderInFixedPointFolder named baldor_utilities
2015-02-19 creating tools classes
2015-02-20 Updated 20FEB
2015-02-21 Creating functions to simplify the python code for connecting with the 4 stm32.
2015-03-03 updating motor tools in python
2015-03-03 finished motor_3 with comments
2015-03-03 Script funciona :D
2015-03-05 not working comunication
2015-03-06 scripts from baldor utils fixed and ready to be proved on the motor
2015-03-13 script.py: xfce4-terminal dimension and title edited.
2015-03-17 Script de Caro
2015-03-20 Carpeta modificada del carrito.
2015-03-24 before returning to a previous version
2015-04-07 updating pid configuration
2015-04-09 X and Y axis where interchanged on src_dc_omnidirectional.
2015-04-10 fixing negative sign on third wheel
2015-04-17 copy the folder resolver_board from master branch to the resolver branch
2015-04-21 reactivating flux-linkage estimator
2015-04-23 src_caro_DTC-SVM: copied src_DTC-SVM project and started modifing the code, first resitance test for the head motors
2015-04-23 change < > by quotes in the #include of the file cdcacm_example.c
2015-04-23 Cleaning the code for the stiffness controller (mainly the SVM.c file)
2015-05-13 FixedPoint: Added new files and results (miscellaneous staff)
2015-09-23 updating SVM algorithm
2016-06-08 baldor control utils: persistent change from int to bool.
2017-06-13 updating libopencm3-plus library dependency
2018-08-07 resolver_test adjusted for brian_pcb1
2018-08-08 baldor_control mods
2019-01-10 brian_pcb1: more changes during pcb testing
2019-01-10 Getting the discovery board flashing again
2019-01-18 closed_loop (baldor control) updated for new PCB rev0.99 board
2019-01-28 creating new velocity control directory. Fixing file naming
2019-01-28 python control program in ascii, more or less complete (send and receive data)
